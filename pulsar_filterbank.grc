<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>pulsar_filterbank</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dsrate</value></param>
<param><key>value</key><value>samp_rate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fbdecim</value></param>
<param><key>value</key><value>int((dsrate/fbsize)/fbrate)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fbrate</value></param>
<param><key>comment</key><value>Output sample rate for each channel</value></param>
<param><key>value</key><value>rates[1]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fbsize</value></param>
<param><key>value</key><value>rates[0]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>hdstatus</value></param>
<param><key>value</key><value>fb_helper.write_header(parmname, freq/1.0e6, dsrate/1.0e6, fbsize, fbrate)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ltp</value></param>
<param><key>value</key><value>time.gmtime(time.time())</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>pacer</value></param>
<param><key>block_id</key><value>pacer_probe</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>[0]*fbsize</value></param>
<param><key>poll_rate</key><value>100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>parmname</value></param>
<param><key>value</key><value>prefix+"psr-"+timestr+".header"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pfname</value></param>
<param><key>value</key><value>prefix+"psr-"+timestr+".rfb16"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rates</value></param>
<param><key>value</key><value>fb_helper.determine_rate(samp_rate)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>srate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>synched</value></param>
<param><key>comment</key><value>For multiple instances, this can help arrange for
the data start times to be *roughly*
synchronized</value></param>
<param><key>value</key><value>fb_helper.synched(startt,pacer)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>timestr</value></param>
<param><key>comment</key><value>Filename forming</value></param>
<param><key>value</key><value>"%04d%02d%02d" % (ltp.tm_year, ltp.tm_mon, ltp.tm_mday)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>bbgain</value></param>
<param><key>label</key><value>Baseband Gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>fbsize</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
<param><key>comment</key><value>"Detect" each channel</value></param>
<param><key>vlen</key><value>fbsize</value></param>
</block>
<block>
<key>blocks_copy</key>
<param><key>id</key><value>blocks_copy_0</value></param>
<param><key>comment</key><value>Allow for rough synchronization</value></param>
<param><key>enabled</key><value>synched</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fbsize</value></param>
</block>
<block>
<key>blocks_deinterleave</key>
<param><key>id</key><value>blocks_deinterleave_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>fbsize</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>pfname</value></param>
<param><key>type</key><value>short</value></param>
<param><key>vlen</key><value>fbsize</value></param>
</block>
<block>
<key>blocks_float_to_short</key>
<param><key>id</key><value>blocks_float_to_short_0</value></param>
<param><key>scale</key><value>32767</value></param>
<param><key>vlen</key><value>fbsize</value></param>
</block>
<block>
<key>blocks_head</key>
<param><key>id</key><value>blocks_head_0</value></param>
<param><key>comment</key><value>So we can control the observation run time</value></param>
<param><key>num_items</key><value>int(runtime*samp_rate)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0</value></param>
<param><key>comment</key><value>Decimate down to our final post-detect
sample rate</value></param>
<param><key>n</key><value>fbdecim</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fbsize</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>fbsize</value></param>
</block>
<block>
<key>blocks_sub_xx</key>
<param><key>id</key><value>blocks_sub_xx_0</value></param>
<param><key>comment</key><value>Cheap high-pass filter</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fbsize</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>device</value></param>
<param><key>label</key><value>Hardware device string</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>airspy=0</value></param>
</block>
<block>
<key>epy_module</key>
<param><key>id</key><value>fb_helper</value></param>
<param><key>source_code</key><value># this module will be imported in the into your flowgraph
import time

#
# Determine FBSIZE and FBRATE given input sample rate
#
# This is not stunningly efficient, but it only has to run
#  ONCE on startup.
#
def determine_rate(srate):
    fbsize_2N = [192,160,128,96,64,48,32,100,50,25]
    for n in fbsize_2N:
        r = rate_core(srate, n)
        if r &gt; 0:
            return((n,r))

    raise RuntimeError("Unable to determine useful FBSIZE/FBRATE combination given sample rate")

#
# Given sample rate, and fbsize, determine a useful rate
#  Return -1 if no rate could be determined
#
def rate_core(srate, fbsize):
    bankrate = float(srate)/float(fbsize)
    for i in range(1800,5600):
        frate = bankrate/float(i)
        irate = float(int(frate))
        if (frate == irate):
            return int(bankrate/irate)
    return -1

def write_header(fn, freq, bw, fbsize, fbrate):
    f = open(fn, "w")
    ltp = time.gmtime(time.time())
    f.write("frequency=%.5f\n" % freq)
    f.write("RF sample rate=%.5f\n" % bw)
    f.write("Filterbank Size=%d\n" % fbsize)
    f.write("Filterbank output rate=%d\n" % fbrate)
    f.write("Approx start UTC Date=%04d%02d%02d\n" % (ltp.tm_year,
        ltp.tm_mon, ltp.tm_mday))
    f.write("Approx start UTC Time=%02d:%02d:%02d\n" % (ltp.tm_hour,
        ltp.tm_min, ltp.tm_sec))
    
def synched(startt,dummy):
    
    if (time.time() &gt; startt):
        return True
    else:
        return False
</value></param>
<param><key>comment</key><value>Helper Module

- determine suitable output sample rate
- determine suitable FB size
- write header info
- provide a synchronization helper</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>fft_size</key><value>fbsize</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>window.blackmanharris(fbsize)</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0_0</value></param>
<param><key>fft_size</key><value>fbsize</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>window.blackmanharris(fbsize)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq</value></param>
<param><key>label</key><value>Tuner Frequency</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>612e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fscale</value></param>
<param><key>label</key><value>Float to byte scaling</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>128</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ifgain</value></param>
<param><key>label</key><value>IF Gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import time</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>bb_gain0</key><value>bbgain</value></param>
<param><key>freq0</key><value>freq</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>ifgain</value></param>
<param><key>gain0</key><value>rfgain</value></param>
<param><key>args</key><value>device</value></param>
<param><key>clock_source0</key><value>external</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>blocks_probe_signal_vx</key>
<param><key>id</key><value>pacer_probe</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fbsize</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>prefix</value></param>
<param><key>label</key><value>File prefix</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"./"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rfgain</value></param>
<param><key>label</key><value>RF Gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>15</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>runtime</value></param>
<param><key>label</key><value>Total runtime (seconds)</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>600</value></param>
</block>
<block>
<key>single_pole_iir_filter_xx</key>
<param><key>id</key><value>single_pole_iir_filter_xx_0</value></param>
<param><key>alpha</key><value>1.0/(float(fbdecim)/2.0)</value></param>
<param><key>comment</key><value>A bit of low-pass filtering</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fbsize</value></param>
</block>
<block>
<key>single_pole_iir_filter_xx</key>
<param><key>id</key><value>single_pole_iir_filter_xx_0_0</value></param>
<param><key>alpha</key><value>1.0/(fbrate*3)</value></param>
<param><key>comment</key><value>Estimate DC</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fbsize</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>srate</value></param>
<param><key>label</key><value>Hardware Sample Rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>10e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>startt</value></param>
<param><key>label</key><value>Start Time</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>int(time.time())</value></param>
</block>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>single_pole_iir_filter_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_copy_0</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_copy_0</source_block_id><sink_block_id>single_pole_iir_filter_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0</source_block_id><sink_block_id>fft_vxx_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_short_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_head_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0</source_block_id><sink_block_id>blocks_copy_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0</source_block_id><sink_block_id>pacer_probe</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>blocks_deinterleave_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_sub_xx_0</source_block_id><sink_block_id>blocks_float_to_short_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>blocks_head_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>single_pole_iir_filter_xx_0</source_block_id><sink_block_id>blocks_keep_one_in_n_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>single_pole_iir_filter_xx_0_0</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
</flow_graph>
