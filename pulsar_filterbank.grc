<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>pulsar_filterbank</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>an_fftsize</value></param>
<param><key>value</key><value>2048</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>analyser_result</value></param>
<param><key>value</key><value>fb_helper.analyser(analysis_poll_fast,fbsize)</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>analysis_poll_fast</value></param>
<param><key>block_id</key><value>analysis_probe</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>[0.0]*an_fftsize</value></param>
<param><key>poll_rate</key><value>4</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>analysis_poll_slow</value></param>
<param><key>block_id</key><value>analysis_probe</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>[0.0]*an_fftsize</value></param>
<param><key>poll_rate</key><value>0.3333</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cfname</value></param>
<param><key>value</key><value>"/dev/null" if wide == 1 else pfname+".filtmp"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fbdecim</value></param>
<param><key>value</key><value>fb_helper.determine_rate(samp_rate,fbsize,pw50)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fbrate</value></param>
<param><key>comment</key><value>Output sample rate for each channel</value></param>
<param><key>value</key><value>(float(samp_rate)/float(fbsize))/float(fbdecim)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fbsize</value></param>
<param><key>value</key><value>fb_helper.dm_to_bins(dm,fb_helper.get_sky_freq(sky,freq),samp_rate,pw50)*resolution</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_log_status</value></param>
<param><key>comment</key><value>Arrange to log FFT outputs in dB ascii
format every 10 seconds</value></param>
<param><key>value</key><value>fb_helper.log_fft(fb_helper.get_sky_freq(sky,freq),samp_rate,prefix,fft_poll2)</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>fft_poll</value></param>
<param><key>block_id</key><value>fft_probe</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>[1.0e-15]*fbsize</value></param>
<param><key>poll_rate</key><value>50</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>fft_poll2</value></param>
<param><key>block_id</key><value>fft_probe</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>[1.0e-15]*fbsize</value></param>
<param><key>poll_rate</key><value>5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_rate</value></param>
<param><key>value</key><value>samp_rate/fbsize</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>hdr2_stat</value></param>
<param><key>value</key><value>fb_helper.build_header_info(pfname+".fil",source,ra,dec,fb_helper.get_sky_freq(sky,freq),srate,fbrate,fbsize,None,swidth)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>hdstatus</value></param>
<param><key>value</key><value>fb_helper.write_header(parmname, fb_helper.get_sky_freq(sky,freq)/1.0e6, samp_rate/1.0e6, fbsize, fbrate,swidth)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>hpcorner</value></param>
<param><key>value</key><value>(1.0/p0)/20.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>lpcorner</value></param>
<param><key>value</key><value>(1.0/pw50)*2.5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ltp</value></param>
<param><key>value</key><value>time.gmtime(time.time())</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>magn</value></param>
<param><key>value</key><value>fb_helper.get_current_estimate()</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>parmname</value></param>
<param><key>value</key><value>prefix+"psr-"+timestr+".header"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pfname</value></param>
<param><key>value</key><value>prefix+"psr-"+timestr</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>prof_file</value></param>
<param><key>value</key><value>prefix+"psr-"+timestr+"-profile.json" if profile else '/dev/null'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>profile_dec</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>reduced_rate</value></param>
<param><key>value</key><value>fbrate/profile_dec</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rfi_mask</value></param>
<param><key>comment</key><value>Computed statically from RFI list</value></param>
<param><key>value</key><value>fb_helper.static_mask(fb_helper.get_sky_freq(sky,freq),samp_rate,fbsize,rfilist)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rfi_mask2</value></param>
<param><key>comment</key><value>Computed dynamically
using estimate of mean power</value></param>
<param><key>value</key><value>fb_helper.dynamic_mask(fft_poll,rfi_mask,thresh)</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>rx_time_tags</value></param>
<param><key>block_id</key><value>tag_retrieve</value></param>
<param><key>function_name</key><value>current_tags</value></param>
<param><key>value</key><value>[]</value></param>
<param><key>poll_rate</key><value>30</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>srate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sfname</value></param>
<param><key>value</key><value>"/dev/null" if wide == 0 else pfname+".filtmp"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>shaper</value></param>
<param><key>comment</key><value>This provides passband response correction
We merge in to the RFI excision masker, to
eliminate an extra multiply-const</value></param>
<param><key>value</key><value>fb_helper.get_correction(fbsize,rolloff,fft_poll2)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>swidth</value></param>
<param><key>value</key><value>1 if wide == 0 else 2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tag_stash_result</value></param>
<param><key>value</key><value>fb_helper.process_tag(rx_time_tags)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>timestr</value></param>
<param><key>comment</key><value>Filename forming</value></param>
<param><key>value</key><value>"%04d%02d%02d%02d%02d" % (ltp.tm_year, ltp.tm_mon, ltp.tm_mday,ltp.tm_hour,ltp.tm_min)</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>Folder_Block</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
from gnuradio import gr
import time
import json

class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
    """A pulsar folder/de-dispersion block"""

    def __init__(self, fbsize=16,smear=10.0,period=0.714,filename='/dev/null',fbrate=2500,tbins=250,interval=30,tppms="0.0"):  # only default arguments here
        """arguments to this function show up as parameters in GRC"""
        gr.sync_block.__init__(
            self,
            name='Pulsar Folder',   # will show up in GRC
            in_sig=[np.float32],
            out_sig=None
        )
        # if an attribute with the same name as a parameter is found,
        # a callback is registered (properties work, too).

        self.set_output_multiple(fbsize)
        self.delaymap = [0]*fbsize
        delayincr = (smear/1000.0) * float(fbrate)
        delayincr /= float(fbsize)
        delayincr = round(delayincr)
        delayincr = int(delayincr)
        for i in range(fbsize):
            self.delaymap[(fbsize-i)-1] = i*delayincr

        #
        # Needed in a few places
        #
        self.flen = fbsize

        #
        # The pulsar period
        #
        self.p0 = period

        #
        # The derived single-period pulse profile with various shifts
        #
        #
        ppmlist = tppms.split(",")
        self.shifts = []
        for p in ppmlist:
            self.shifts.append(float(p)*1.0e-6)

        self.profiles = [[0.0]*tbins]*len(self.shifts)
        self.pcounts = [[0.0]*tbins]*len(self.shifts)
        self.nprofiles = len(self.profiles)

        #
        #
        # How much time is in each bin?
        # The profile should be "exactly" as long as a single
        #   pulse period
        #
        self.tbint = []
        for shift in self.shifts:
            self.tbint.append((self.p0*(1.0+shift))/tbins)

        #
        # The profile length
        #
        self.plen = tbins

        #
        # Sample period
        #
        self.sper = 1.0/fbrate

        #
        # Mission Elapsed Time
        # This is moved along at every time samples arrival--incremented
        #   by 'self.sper'
        #
        self.MET = 0.0

        #
        # Open the output file
        #
        self.fname = filename
        self.sequence = 0

        self.max_in = 0.0
        self.min_in = 100000000

        #
        # The logging interval
        #
        self.INTERVAL = fbrate*interval
        self.logcount = self.INTERVAL

        #print "tbin %-11.7f tbinp %-11.7f tbinn %-11.7f" % (self.tbin, self.tbinp, self.tbinn)
        fp = open(self.fname, "w")
        fp.write ("[\n")
        fp.close()

    def work(self, input_items, output_items):
        """Do dedispersion/folding"""
        q = input_items[0]
        l = len(q)
        if (l &gt; self.max_in):
            self.max_in = l
        elif (l &lt; self.min_in):
            self.min_in = l
        for i in range(l/self.flen):
            #
            # Do delay/dedispersion logic
            #
            if (self.delaymap[0] &gt; 0):
                outval = 0.0
                for j in range(self.flen):
                    if (self.delaymap[j] == 0):
                        outval += q[(i*self.flen)+j]
                #
                # Decrement delay counters
                #
                for j in range(self.flen):
                    if (self.delaymap[j] &gt; 0):
                        self.delaymap[j] -= 1
                    else:
                        break
            else:
                outval = sum(q[(i*self.flen):(i*self.flen)+self.flen])

            #
            # Figure out where this sample goes in the profile buffer, based on MET
            # We place the next sample based on the MET, re-expressed in terms of
            #   total time-bins (self.tbint) modulo the profile length
            #
            # Update all the profiles
            #
            for x in range(self.nprofiles):
                where = self.MET/self.tbint[x]
                where = int(where) % self.plen
                self.profiles[x][where] += outval
                self.pcounts[x][where] += 1

            #
            # Increment Mission Elapsed Time
            #
            self.MET += self.sper

            #
            # Decrement the log counter
            #
            self.logcount -= 1

            #
            # If time to log, the output is the reduced-by-counts
            #  value of the profile.
            #
            if (self.logcount &lt;= 0):
                fp = open(self.fname, "a")
                outputs = []
                for x in range(len(self.profiles)):
                    outputs.append(np.divide(self.profiles[x],self.pcounts[x]))
                d = {}
                t = time.gmtime()
                d["time"] = "%04d%02d%02d-%02d:%02d:%02d" % (t.tm_year,
                    t.tm_mon, t.tm_mday, t.tm_hour, t.tm_min, t.tm_sec)
                d["sequence"] = self.sequence
                d["max_input_length"] = self.max_in
                d["min_input_length"] = self.min_in
                self.sequence += 1
                profiles = []
                for x in range(len(self.profiles)):
                    pd = {}
                    pd["profile"] = list(outputs[x])
                    pd["p0"] = self.p0*(1.0+self.shifts[x])
                    pd["shift"] = self.shifts[x]
                    profiles.append(pd)
                d["profiles"] = profiles
                fp.write(json.dumps(d, indent=4, sort_keys=True)+",\n")
                fp.close()
                self.logcount = self.INTERVAL


        return len(q)
</value></param>
<param><key>fbrate</key><value>reduced_rate</value></param>
<param><key>fbsize</key><value>fbsize</value></param>
<param><key>filename</key><value>prof_file</value></param>
<param><key>interval</key><value>pinterval</value></param>
<param><key>period</key><value>p0</value></param>
<param><key>smear</key><value>fb_helper.dm_to_smear(freq,samp_rate,dm)</value></param>
<param><key>tbins</key><value>tbins</value></param>
<param><key>tppms</key><value>trial_ppms</value></param>
</block>
<block>
<key>analog_fastnoise_source_x</key>
<param><key>id</key><value>analog_fastnoise_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>type</key><value>float</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>samples</key><value>int(2.0e6)</value></param>
</block>
<block>
<key>blocks_probe_signal_vx</key>
<param><key>id</key><value>analysis_probe</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>an_fftsize</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>bbgain</value></param>
<param><key>label</key><value>Baseband Gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>blocks_abs_xx</key>
<param><key>id</key><value>blocks_abs_xx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fbsize</value></param>
</block>
<block>
<key>blocks_abs_xx</key>
<param><key>id</key><value>blocks_abs_xx_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fbsize</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fbsize</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_2</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fbsize</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_0</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
<param><key>comment</key><value>"Detect" each channel</value></param>
<param><key>vlen</key><value>fbsize</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_1</value></param>
<param><key>vlen</key><value>an_fftsize</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>append</key><value>True</value></param>
<param><key>file</key><value>cfname</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>fbsize</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>append</key><value>True</value></param>
<param><key>file</key><value>sfname</value></param>
<param><key>type</key><value>short</value></param>
<param><key>vlen</key><value>fbsize</value></param>
</block>
<block>
<key>blocks_float_to_char</key>
<param><key>id</key><value>blocks_float_to_char_0</value></param>
<param><key>comment</key><value>Whether we produce 8-bit or 16-bit files
depends on the "wide" input parameter.</value></param>
<param><key>scale</key><value>float(dscale) if dscale &gt;= 0 else fb_helper.autoscale(abs(dscale),fft_poll2)</value></param>
<param><key>vlen</key><value>fbsize</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
<param><key>comment</key><value>Flip I/Q, effect spectral inversion</value></param>
</block>
<block>
<key>blocks_float_to_short</key>
<param><key>id</key><value>blocks_float_to_short_0</value></param>
<param><key>scale</key><value>float(dscale) if dscale &gt;= 0 else fb_helper.autoscale(abs(dscale),fft_poll2)</value></param>
<param><key>vlen</key><value>fbsize</value></param>
</block>
<block>
<key>blocks_head</key>
<param><key>id</key><value>blocks_head_0</value></param>
<param><key>comment</key><value>So we can control the observation run time</value></param>
<param><key>num_items</key><value>int(runtime*samp_rate)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_integrate_xx</key>
<param><key>id</key><value>blocks_integrate_xx_0</value></param>
<param><key>decim</key><value>fbdecim</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fbsize</value></param>
</block>
<block>
<key>blocks_integrate_xx</key>
<param><key>id</key><value>blocks_integrate_xx_1</value></param>
<param><key>decim</key><value>fbsize</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0</value></param>
<param><key>comment</key><value>Decimate down to post-detect rate</value></param>
<param><key>n</key><value>fbdecim</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fbsize</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_1</value></param>
<param><key>n</key><value>int(samp_rate/15.0)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_2</value></param>
<param><key>n</key><value>10</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fbsize</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_3</value></param>
<param><key>n</key><value>profile_dec if profile == 1 else 100</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fbsize</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>comment</key><value>First stage RFI excision</value></param>
<param><key>const</key><value>numpy.multiply(rfi_mask2,shaper)</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fbsize</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1</value></param>
<param><key>const</key><value>[0.0] * fbsize if hp == 0 else [hpgain]*fbsize</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fbsize</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_2</value></param>
<param><key>const</key><value>fb_helper.invert_rfi_mask(rfi_mask2)*numpy.array([magn]*fbsize)</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fbsize</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_3</value></param>
<param><key>const</key><value>[float(fbdecim)]*fbsize if integrator == 0 else [0.0]*fbsize</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fbsize</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_4</value></param>
<param><key>const</key><value>[1.0]*fbsize if integrator == 1 else [0.0]*fbsize</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fbsize</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_5</value></param>
<param><key>comment</key><value>This effectively selects which channel we are
currently observing for detected modulation
artifacts</value></param>
<param><key>const</key><value>fb_helper.get_current_channel(analysis_poll_slow,fbsize)</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fbsize</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>fbsize</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>fbsize</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_2</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>an_fftsize</value></param>
</block>
<block>
<key>blocks_sub_xx</key>
<param><key>id</key><value>blocks_sub_xx_0</value></param>
<param><key>comment</key><value>Implement DC block
Subtract long-term average from current
samples</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fbsize</value></param>
</block>
<block>
<key>blocks_tags_strobe</key>
<param><key>id</key><value>blocks_tags_strobe_0</value></param>
<param><key>key</key><value>pmt.intern("local_tick")</value></param>
<param><key>nsamps</key><value>1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>value</key><value>pmt.from_bool(True)</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>fbsize</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>fbsize</value></param>
</block>
<block>
<key>blocks_copy</key>
<param><key>id</key><value>copyblock</value></param>
<param><key>enabled</key><value>True</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>dec</value></param>
<param><key>label</key><value>Source DEC</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>54.5</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>device</value></param>
<param><key>label</key><value>Hardware device string</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"airspy=0"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>dm</value></param>
<param><key>label</key><value>Dispersion Measure</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>28.3</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>dscale</value></param>
<param><key>label</key><value>Detector scaling</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>epy_module</key>
<param><key>id</key><value>fb_helper</value></param>
<param><key>source_code</key><value># this module will be imported in the into your flowgraph
import time
import os
import shutil
import math
import struct
import pmt
import numpy
import random

smpwidth = 0

#
# Determine reasonable decimation value, given sample-rate,
#  filterbank-size (already determined) and pw50 for the
#  target pulsar.
#
# This is not stunningly efficient, but it only has to run
#  ONCE on startup.
#
def determine_rate(srate,fbsize,pw50):
    decims = [1024,512,256,128,64,32,16,8,4,2,1]
    target_rate = (1.0/pw50)
    target_rate *= 10.0
    for d in decims:
        if ((srate/fbsize)/d &gt;= target_rate):
            return d
    return 1

def dm_to_smear(freq,bw,dm):
    f_lower = (freq-(bw/2.0))*1.0e-6
    f_upper = (freq+(bw/2.0))*1.0e-6
    Dt = 4.15e6 * (math.pow(f_lower,-2.0)-math.pow(f_upper,-2.0))
    Dt *= dm
    return Dt

#
# Convert DM to a reasonable number of FFT bins, given
#  DM, center-frequency, bandwidth, and pw50
#
def dm_to_bins(dm,freq,bw,pw50):

    #
    # Convert pw50 to milliseconds (sigh)
    #
    p50ms = pw50 * 1000.0

    Dt = dm_to_smear(freq,bw,dm)

    #
    # So that there's only 25% (of W50) residual smearing in each channel of the FB
    #
    required_bins = Dt/(p50ms/4.0)

    #
    # We do a bit of base2 math to make this a nice FFT size
    #
    bins = math.log(required_bins)/math.log(2.0)
    if (abs(bins-int(bins)) &gt; 0.2):
        bins += 1

    bins = int(bins)

    #
    # No sense making the filterbank too small
    # Set bins so that minimum is 4 channels
    if bins &lt; 2:
        bins = 2

    return(int(2**bins))

#
# Write an external, text, header file
#
def write_header(fn, freq, bw, fbsize, fbrate, smpsize):
    global smpwidth

    if (smpwidth == 0):
        smpwidth = smpsize

    f = open(fn, "w")
    ltp = time.gmtime(time.time())
    f.write("frequency=%.5f\n" % freq)
    f.write("RF sample rate=%.5f\n" % bw)
    f.write("Filterbank Size=%d\n" % fbsize)
    f.write("Filterbank output rate=%.6f\n" % fbrate)
    f.write("Approx start UTC Date=%04d%02d%02d\n" % (ltp.tm_year,
        ltp.tm_mon, ltp.tm_mday))
    f.write("Approx start UTC Time=%02d:%02d:%02d\n" % (ltp.tm_hour,
        ltp.tm_min, ltp.tm_sec))
    f.write("Output sample size %d bytes\n" % smpsize)
    f.write("Expected disk write rate: %6.2f mbyte/sec\n" % ((fbsize*fbrate*smpsize)/1.0e6))



header_args = {}

#
# Convert to the weirdness that is the hybrid floating-point
#  time format used by SIGPROC
#
def convert_sigproct(v):
    itime = int(v*3600.0)
    hours = itime/3600
    minutes = (itime-(hours*3600))/60
    seconds = itime - (hours*3600) - (minutes*60)
    timestr="%02d%02d%02d.0" % (hours, minutes, seconds)
    return(float(timestr))


def tobytes(s):
    """converts specified parameter to bytes. Python 3 is much more picky regarding
       differences between strings and bytes. This function is used in build_header_info()"""
    return bytes(str(s),'utf-8')

#
# This will cause a header block to be prepended to the output file
#
# Thanks to Guillermo Gancio (ganciogm@gmail.com) for the inspiration
# and much of the code. Adjusted to python 3 by Tomek Mrugalski.
#
def build_header_info(outfile,source_name,source_ra,source_dec,freq,bw,fbrate,fbsize,rx_time,smpsize):
    global smpwidth

    if (smpwidth == 0):
        smpwidth = smpsize

    header_args["outfile"] = outfile
    header_args["source_name"] = source_name
    header_args["source_ra"] = source_ra
    header_args["source_dec"] = source_dec
    header_args["freq"] = freq
    header_args["bw"] = bw
    header_args["fbrate"] = fbrate
    header_args["fbsize"] = fbsize

    #
    # Time for one sample, in sec
    #
    tsamp=1.0/fbrate

    #
    # Frequency offset between channels, in MHz
    #
    f_off=bw/fbsize
    f_off /= 1.0e6
    f_off *= -1

    #
    # Highest frequency represented in FB, in MHz
    #
    high_freq = freq+(bw/2.0)
    high_freq  /= 1.0e6
    high_freq -= (f_off/2.0)

    #
    # Lowest
    #
    low_freq = freq-(bw/2.0)
    low_freq /= 1.0e6
    low_freq += (f_off/2.0)

    #
    # Number of subbands
    #
    sub_bands=fbsize

    #
    # Determine MJD from file timestamp. Open the output file as binary.
    #
    if (rx_time == None):
        fp = open(outfile, "wb")
        t_start = (os.path.getmtime(outfile) / 86400) + 40587
    else:
        fp = open(outfile, "wb")
        t_start = rx_time

    #
    # The rest here is mostly due to Guillermo Gancio ganciogm@gmail.com
    #
    stx=tobytes("HEADER_START")
    etx=tobytes("HEADER_END")
    fp.write(struct.pack('i', len(stx))+stx)
    fp.flush()

    #--
    aux=tobytes("rawdatafile")
    aux=struct.pack('i', len(aux))+aux
    fp.write(aux)
    fp.write(struct.pack('i', len(outfile))+tobytes(outfile))

    #--
    aux=tobytes("src_raj")
    aux=struct.pack('i', len(aux))+aux
    source_ra = convert_sigproct(source_ra)
    fp.write(aux)
    aux=struct.pack('d', source_ra)
    fp.write(aux)
    fp.flush()

    #--
    aux=tobytes("src_dej")
    aux=struct.pack('i', len(aux))+aux
    fp.write(aux)
    source_dec= convert_sigproct(source_dec)
    aux=struct.pack('d', source_dec)
    fp.write(aux)
    #--

    aux=tobytes("az_start")
    aux=struct.pack('i', len(aux))+aux
    fp.write(aux)
    aux=struct.pack('d', 0.0)
    fp.write(aux)
    #--
    aux=tobytes("za_start")
    aux=struct.pack('i', len(aux))+aux
    fp.write(aux)
    aux=struct.pack('d', 0.0)
    fp.write(aux)
    #--
    aux=tobytes("tstart")
    aux=struct.pack('i', len(aux))+aux
    fp.write(aux)
    aux=struct.pack('d', float(t_start))
    fp.write(aux)
    #--
    aux=tobytes("foff")
    aux=struct.pack('i', len(aux))+aux
    fp.write(aux)
    aux=struct.pack('d', f_off)
    fp.write(aux)
    #--
    aux=tobytes("fch1")
    aux=struct.pack('i', len(aux))+aux
    fp.write(aux)
    aux=struct.pack('d', high_freq)
    fp.write(aux)
    #--
    aux=tobytes("nchans")
    aux=struct.pack('i', len(aux))+aux
    fp.write(aux)
    aux=struct.pack('i', sub_bands)
    fp.write(aux)
    #--
    aux=tobytes("data_type")
    aux=struct.pack('i', len(aux))+aux
    fp.write(aux)
    aux=struct.pack('i', 1)
    fp.write(aux)
    #--


    aux=tobytes("ibeam")
    aux=struct.pack('i', len(aux))+aux
    fp.write(aux)
    aux=struct.pack('i', 1)
    fp.write(aux)
    #--
    aux=tobytes("nbits")
    aux=struct.pack('i', len(aux))+aux
    fp.write(aux)
    aux=struct.pack('i', smpsize*8)
    fp.write(aux)
    #--


    aux=tobytes("tsamp")
    aux=struct.pack('i', len(aux))+aux
    fp.write(aux)
    aux=struct.pack('d', tsamp)
    fp.write(aux)
    #--
    aux=tobytes("nbeams")
    aux=struct.pack('i', len(aux))+aux
    fp.write(aux)
    aux=struct.pack('i', 1)
    fp.write(aux)


    #--
    aux=tobytes("nifs")
    aux=struct.pack('i', len(aux))+aux
    fp.write(aux)
    aux=struct.pack('i', 1)
    fp.write(aux)

    #--
    aux=tobytes("source_name")
    fp.write(struct.pack('i', len(aux))+aux)
    fp.write(struct.pack('i', len(source_name)) + tobytes(source_name))


    #--
    aux=tobytes("machine_id")
    aux=struct.pack('i', len(aux))+aux
    fp.write(aux)
    aux=struct.pack('i', 20)
    fp.write(aux)
    #--
    aux=tobytes("telescope_id")
    aux=struct.pack('i', len(aux))+aux
    fp.write(aux)
    aux=struct.pack('i', 20)
    fp.write(aux)
    #--
    fp.write(struct.pack('i', len(etx))+etx)
    fp.flush()
    fp.close
    return True

def auto_to_freqs(mask, freq, bw):
    start = freq+(bw/2)
    bins = len(mask)
    decr = bw/bins
    flist = ""
    for i in range(len(mask)):
        if (mask[i] == 0.0):
            flist += "%8.4f," % (start/1.0e6)
        start -= decr
    return flist
#
# We're called fairly frequently, but we only want to log every 10 seconds
#
next_fft = time.time() + 10.0
smooth_fft = [0.0]
fft_cnt = 0
last_smooth = time.time()
def log_fft(freq,bw,prefix,fft):
    global next_fft
    global automask
    global smooth_fft
    global fft_cnt
    global last_smooth

    #
    # Degenerate FFT length--sometimes on startup
    #
    if (len(fft) &lt; 2):
        return

    #
    # Provide "smooth" FFT for get_correction
    #  function
    #
    if ((time.time() - last_smooth) &gt;= 1.5):
        if (len(smooth_fft) != len(fft)):
            smooth_fft = numpy.array([0.0]*len(fft))
        fft_cnt += 1
        smooth_fft = numpy.add(fft,smooth_fft)
        last_smooth = time.time()
    #
    # Not yet time
    #
    if (time.time() &lt; next_fft):
        return

    #
    # Schedule our next one
    #
    next_fft = time.time() + 10.0

    #
    # Get current time, break out into "struct tm" style time fields
    #
    ltp = time.gmtime(time.time())

    #
    # Constract filename from parts
    #
    date = "%04d%02d%02d%02d" % (ltp.tm_year, ltp.tm_mon, ltp.tm_mday, ltp.tm_hour)
    fp = open(prefix+"psr-"+date+"-fft.csv", "a")

    #
    # Write UTC header
    #
    fp.write("%02d:%02d:%02d," % (ltp.tm_hour, ltp.tm_min, ltp.tm_sec))

    #
    # Spectrum is inverted:  Fc+bw/2 to Fc-bw/2
    #
    # Required for PRESTO tooling
    # So we start at the high end and work our way backwards
    #
    for i in range(len(fft)-1,-1,-1):
        if (fft[i] &lt;= 0.0):
            fp.write("??,")
        else:
            fp.write("%.2f," % (10.0*math.log10(fft[i]/len(fft))))
    fp.write("\n")
    fp.close()

    mf = open (prefix+"psr-"+date+"-automask.txt", "w")
    mf.write (auto_to_freqs(automask,freq,bw))
    mf.close()



#
# This is called from a 10s-of-Hz poll with a list of "current_tags"
#
# We record the time that the first tag flashes past us.
#
#
# We maintain a static tag dictionary for use later by the header
#  update code
#
tag_dict = {}
first_tag = None
def process_tag(tags):
    global first_tag
    for tag in tags:
        tag_dict[pmt.to_python(tag.key)] = pmt.to_python(tag.value)
        if (first_tag == None):
            first_tag = time.time()

#
# Used to find a tag in the tag_dict
#
def get_tag(key):
    if (key in tag_dict):
        return (tag_dict[key])
    else:
        return None

didit = False
#
# Basically, near the end of the run, concatenates the correct header data
#  and the live sample data, and produces a final ".fil" output file.
#
def update_header(pacer,runtime,smpsize):
    global didit
    global first_tag
    import time
    import shutil
    import os
    global smpwidth

    if (smpwidth == 0):
        smpwidth = smpsize

    #
    # If we haven't seen our first tag yet, data flow hasn't started
    #
    # The first tag showing up triggers us to record the local time.
    #
    # This allows us to form a rough estimate of when to do the
    #  file-merge, and also, will be our starting timestamp if the
    #  data stream never had an rx_time tag.
    #
    #
    if (runtime != None):
        if (first_tag == None):
            return None
        else:
            endtime = first_tag + runtime
            endtime -= 0.5
    #
    # We're being called as an exit handler
    #
    else:
        endtime = time.time() - 30.0
        didit = False

    #
    # This little dance ensures that we only update the header and concatenate
    #   the live sample data when:
    #
    #   o   We're close to the end of the run
    #   o   We haven't already done this
    #
    if ((time.time() &gt;= endtime) and didit == False):

        #
        # We retrieve the previously-cached "rx_time" tag
        #
        # If "none", then we use "first_tag" value
        #
        times = get_tag("rx_time")
        if (times != None):
            seconds = float(times[0])+float(times[1])
        else:
            #
            # This will result in a very-rough approximation
            #
            if (first_tag != None):
                seconds = first_tag
            else:
                seconds = time.time()
            print("No rx_time tag, start time will be approximate.")

        #
        # Turn real seconds into MJD
        #
        MJD = seconds/86400.0
        MJD += 40587.0
        build_header_info(header_args["outfile"],
            header_args["source_name"],
            header_args["source_ra"],
            header_args["source_dec"],
            header_args["freq"],
            header_args["bw"],
            header_args["fbrate"],
            header_args["fbsize"],
            MJD,smpsize)
        dataname = header_args["outfile"].replace(".fil", ".filtmp")
        try:
            inf = open(dataname, "r")
            outf = open(header_args["outfile"], "a")
            #
            # Concatenate the live sample data onto the .fil file, which
            #   at this point, only contains the header data
            #
            shutil.copyfileobj(inf, outf)
            inf.close()
            outf.close()
            didit = True
            #
            # We don't need the ".filtmp" file anymore, blow it away
            #
            os.remove(dataname)
        except:
            pass

    return None

def get_swidth():
    return smpwidth

#
# Calculate a "static" RFI mask--basically a vector of either 1.0 or 0.0
#   depending on whether this bin is "in" or excised
#
# Input is an RFI list, as a string, with comma-separated frequency values
#   in Hz.
#
# This mask will get multiplied by the filterbank outputs--so at a position
#   with a "1.0", that filterbank bin will be included, else it won't.
#
def static_mask(freq,bw,fbsize,rfilist):

    #
    # If no RFI list, the mask is all 1.0
    #
    if (rfilist == "" or len(rfilist) == 0 or rfilist == None):
        return ([1.0]*fbsize)

    #
    # Step size is the bandwidth over the filterbank size
    #   (bin width, basically, in Hz)
    #
    step = bw/fbsize
    start = freq-(bw/2.0)
    end = freq+(bw/2.0)

    #
    # Parse the RFI list, do a little sanity checking
    #  on the values.
    #
    rfi = rfilist.split(",")
    mask = [1.0]*fbsize
    for r in rfi:
        try:
            ndx = float(r)-start
            ndx = ndx/step
            ndx = int(ndx)
            if (ndx &gt;= 0 and ndx &lt; len(mask)):
                mask[ndx] = 0.0
        except:
            pass
    mask.reverse()
    return(mask)

#
# Compute a "dynamic mask".  This is part of a two-stage process for
#  implementing spectral-based RFI excision.  The first stage "blanks"
#  the excised channels.  The second stage arranges for the "blanked"
#  channels to have a median estimate +/- a small amount of noise
#  in them.  This is better than a sudden "empty" channel for post-facto
#  folding.
#
# Since this second mask is incorporated by a vector addition operation, the
#  "good" channels will have a 0.0 in the mask, and the "bad" channels
#  will have the locally-estimated mean in them.
#
count=0
deviation=0.0
automask=None
current_estimate=0.0
def dynamic_mask(fft,smask,thresh):
    global count
    global deviation
    global automask
    global current_estimate



    if (automask == None):
        automask = [1.0]*len(fft)

    #
    # Our ultimate mask is based on both the user-input static mask
    #  and the dynamically-determined mask
    #
    smask = list(numpy.multiply(smask,automask))

    #
    # How many blanked/excised channels in the static mask?
    #
    nzero = smask.count(0.0)

    #
    # Determine trim range
    #
    # (Python 3 update: make sure the ff is integer. Arrays can only be
    # indexed by integers)
    lf = len(fft)
    ff = int(lf/10)
    if (ff == 0):
        ff = 1

    #
    # Calculate mean deviation, but only occasionally
    # Update automask, but only occasionally
    #
    if ((count % 15) == 0):
        #
        # Make "trimmed" versions of mask and input FFT
        #
        trim_fft = fft[ff:-ff]
        trim_mask = list(smask[ff:-ff])

        #
        # Compute a quick mean
        # Since the trim_fft bins at the trim_mask excision locations will
        #    be zero, we can use "sum" with confidence
        #
        #
        # The count for the mean will be the length of the input,
        #   minus the number of zeros in the mask
        #
        mcount = len(trim_fft)-trim_mask.count(0.0)
        dmean = sum(numpy.multiply(trim_fft,trim_mask))
        dmean /= mcount

        #
        # Now compute average deviation
        #
        adev = 0.0
        for i in range(len(trim_fft)):
            if (trim_mask[i]):
                adev += abs(trim_fft[i]-dmean)

        #
        # Automask looks for FFT values that exceed the current
        #  mean estimate by a significant factor--a pulsar will
        #  never do this.  Sporadic narrowband RFI will.
        #
        #
        for i in range(len(fft)):

            #
            # Bigger than threshold? It goes on the automask
            #  AND NEVER LEAVES!  This prevents oscillation
            #  over timescales that would be similar to pulsars...
            #
            if (fft[i] &gt; (dmean*thresh)):
                automask[i] = 0.0

        #
        # Two-point smoothing on deviation
        #
        if (deviation != 0.0):
            deviation += adev/mcount
            deviation /= 2.0
        else:
            deviation = adev/mcount

    count +=1

    #
    # Compute the mean
    # First: apply the mask
    #
    # We add up all the non-masked channels
    #
    mean = numpy.multiply(smask,fft)
    mean = mean[ff:-ff]
    lnm = len(mean)
    mean = sum(mean)

    #
    # Then: divide by length - count of blanked channels
    #  (divide by count of non-masked channels, IOW)
    #
    mean = mean/float(lnm-nzero)
    mask = [0.0]*len(smask)
    current_estimate = mean
    i = 0
    if False:
        for s in smask:

            #
            # We apply the locally-estimated mean, and then dither by a
            #  small amount--this makes sure that the correlation of the
            #  blanked channels tends to be poor.  I hope.
            #
            if (s &lt; 1.0):
                mask[i] = random.uniform(mean-(deviation/2.0),mean+(deviation/2.0))
            i += 1

    return(smask)

def invert_rfi_mask(mask):
    rmask = []
    for i in range(0,len(mask)):
        rmask.append(1.0 if mask[i] == 0.0 else 0.0)
    return rmask

estithen = time.time()
frozen_estimate = 0.0
def get_current_estimate():
    global current_estimate
    global frozen_estimate

    if (time.time() - estithen &lt; 90):
        frozen_estimate = current_estimate
        return current_estimate
    else:
        return frozen_estimate

#
# Compute passband flatness correction
#
# Use the middle 8 bins as an average to normalize to
#
last_correct = time.time()
correct_state = 0
correction = [0.0]
def get_correction(fbsize,correct,pacer):
    global last_correct
    global smooth_fft
    global fft_cnt
    global correct_state
    global correction

    #
    # They haven't asked for correction
    #
    if (correct == 0):
        return [1.0]*fbsize

    #
    # If time to return a correction estimate
    #
    if ((time.time() - last_correct) &gt; 90):
        # Compute correction if we haven't already done so
        if (correct_state == 0):
            correct_state = 1

            #
            # Compute the fraction of the buffer we're ignoring
            #  for calculation of the average level
            #
            frac = int(fbsize/6)

            #
            # Reduce smooth by fft_cnt
            #
            smooth_fft = numpy.divide(smooth_fft,fft_cnt)
            fft_cnt = 1

            #
            # Produce the "window" over which we'll average
            #
            avg_window = smooth_fft[frac:-frac]

            #
            # Average that "window"
            #
            avg = sum(avg_window)
            avg /= float(len(avg_window))


            #
            # Compute the ratio between the average and the smoothed FFT, and
            #  produce a scaling vector that makes them all roughly at the same level
            #
            # We only do thiS ONCE in an entire run near the beginning,
            #   otherwise, other bad things will happen
            #
            # This should be OK, since the *ratios* should remain roughly
            #  the same, even if the baseline noise level changes, due to
            #  background continuum level changes, etc.
            #
            correction = numpy.divide([avg]*fbsize,smooth_fft)
        return correction
    #
    # Not yet time, return no correction
    #
    else:
        return [1.0]*fbsize

def get_sky_freq(sky,freq):
    return sky if sky != 0.0 else freq

def autoscale(scale,pace):
    p = get_current_estimate()
    if (p &gt; 1.0e-12):
        return float(scale/p)
    else:
        return 1.0

current_channel = 0
def get_current_channel(pacer,nchan):
    global current_channel

    r = [0.0]*nchan
    r[current_channel] = 1.0
    current_channel += 1
    if (current_channel &gt;= nchan):
        current_channel = 0
    return r

channels = None
chcnts = None
spikes = None
lastchan = -1
def analyser(fft,nchan):
    global automask
    global channels
    global chcnts
    global spikes
    global lastchan

    # python 3 fix: indices must be integers
    nfft = fft[0:int(len(fft)/2)]
    if channels == None:
        channels = [numpy.array([0.0]*len(nfft))]*nchan
        chcnts = [0.0]*nchan
        spikes = [0]*nchan

    ccn = current_channel
    channels[ccn] = numpy.add(nfft,channels[ccn])
    chcnts[ccn] += 1.0

    #
    # Ignore if this is the first data after a channel change
    #
    if (ccn != lastchan):
        #print "New channel %d" % ccn
        lastchan = ccn
        return ccn

    chavg = numpy.divide(channels[ccn], chcnts[ccn])

    spike = 0
    winsize = 6
    if (chcnts[ccn] &gt; 10):
        for inspected in range(winsize,len(chavg)-winsize):
            window = sum(chavg[inspected-winsize:inspected-1])
            window /= float(winsize)
            if (chavg[inspected] &gt; window*3.5):
                spike += 1

        if (spike == 0):
            if (spikes[ccn] &gt; 0):
                spikes[ccn] -=1

        elif (spike &gt; 1):
            spikes[ccn] += 1

        if (spikes[ccn] &gt; 10):
            automask[ccn] = 0.0

    return ccn

</value></param>
<param><key>comment</key><value>Helper Module

- determine suitable output sample rate
- determine suitable FB size
- write header info
- provide a synchronization helper
- provide a .FIL file header writer
- process rx_time tag and update header
- do RFI estimation and mask generation
- compute passband correction
- provide auto-scale option for output</value></param>
</block>
<block>
<key>blocks_probe_signal_vx</key>
<param><key>id</key><value>fft_probe</value></param>
<param><key>comment</key><value>This operates at fbrate
Used for FFT logging
And estimation of the mean</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fbsize</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>fft_size</key><value>an_fftsize</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>float</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>window.blackmanharris(an_fftsize)</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0_0</value></param>
<param><key>fft_size</key><value>fbsize</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>window.blackmanharris(fbsize)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq</value></param>
<param><key>label</key><value>Tuner Frequency</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>612e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>hp</value></param>
<param><key>label</key><value>HP pass enable</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>hpgain</value></param>
<param><key>label</key><value>High Pass pseudo-gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ifgain</value></param>
<param><key>label</key><value>IF Gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import time</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>import platform</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_1</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_1</value></param>
<param><key>import</key><value>import atexit</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_1_0</value></param>
<param><key>import</key><value>import numpy</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>integrator</value></param>
<param><key>label</key><value>Enable straight integrator instead of IIR</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>comment</key><value>A sub-graph to do analysis of the
*detected* spectrum.

This allows us to look for RFI components in a
channel that may be only a wee bit above the
average noise floor, and thus may fail to
trigger the RF spectral excision.

One channel is analysed at a time, in a
round-robin schedule.

This eliminates having to have &lt;fbsize&gt;
independent FFTs running in parallel.</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_1</value></param>
<param><key>comment</key><value>The trick here is to decimate the input so that
the input to the tag_debug is slowed down to
10-15SPS, via the keep-one-in-N.

This is because tag_debug resets its
local cache of tags every time its work
function is called, which at high sample
rates means 0 probability of catching it
in a "full" state.</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmo_radio</value></param>
<param><key>bb_gain0</key><value>bbgain</value></param>
<param><key>bw0</key><value>samp_rate</value></param>
<param><key>freq0</key><value>freq</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>ifgain</value></param>
<param><key>gain0</key><value>rfgain</value></param>
<param><key>args</key><value>device</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>clock_source0</key><value>refclock</value></param>
<param><key>time_source0</key><value>pps</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>p0</value></param>
<param><key>label</key><value>Pulsar P0</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.714520</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pinterval</value></param>
<param><key>label</key><value>Interval for logging profile</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>30</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pps</value></param>
<param><key>label</key><value>PPS source</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"internal"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>prefix</value></param>
<param><key>label</key><value>File prefix</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"./"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>profile</value></param>
<param><key>label</key><value>Log Rough Profile</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pw50</value></param>
<param><key>label</key><value>Pulsar PW50</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>6.6e-3</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ra</value></param>
<param><key>label</key><value>Source RA</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>3.51</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>refclock</value></param>
<param><key>label</key><value>Reference Clock Source</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"internal"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>resolution</value></param>
<param><key>label</key><value>FB resolution multiplier</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rfgain</value></param>
<param><key>label</key><value>RF Gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>15</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rfilist</value></param>
<param><key>label</key><value>RFI frequency list</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>""</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rolloff</value></param>
<param><key>label</key><value>Enable Roll-off correction</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>runtime</value></param>
<param><key>label</key><value>Total runtime (seconds)</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>600</value></param>
</block>
<block>
<key>single_pole_iir_filter_xx</key>
<param><key>id</key><value>single_pole_iir_filter_xx_0</value></param>
<param><key>alpha</key><value>1.0-math.pow(math.e,-2.0*(lpcorner/(fft_rate)))</value></param>
<param><key>comment</key><value>A bit of low-pass filtering</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fbsize</value></param>
</block>
<block>
<key>single_pole_iir_filter_xx</key>
<param><key>id</key><value>single_pole_iir_filter_xx_1</value></param>
<param><key>alpha</key><value>1.0-math.pow(math.e,-2.0*(hpcorner/(fbrate)))</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fbsize</value></param>
</block>
<block>
<key>single_pole_iir_filter_xx</key>
<param><key>id</key><value>single_pole_iir_filter_xx_2</value></param>
<param><key>alpha</key><value>1.0-math.pow(math.e,-2.0*(20.0/fbrate))</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fbsize</value></param>
</block>
<block>
<key>single_pole_iir_filter_xx</key>
<param><key>id</key><value>single_pole_iir_filter_xx_3</value></param>
<param><key>alpha</key><value>0.1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>an_fftsize</value></param>
</block>
<block>
<key>single_pole_iir_filter_xx</key>
<param><key>id</key><value>single_pole_iir_filter_xx_4</value></param>
<param><key>alpha</key><value>1.0/5.0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sky</value></param>
<param><key>label</key><value>Sky Frequency</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>source</value></param>
<param><key>label</key><value>Source Name</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"B0329+54"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>srate</value></param>
<param><key>label</key><value>Hardware Sample Rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>5.0e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>subdev</value></param>
<param><key>label</key><value>Subdev spec, UHD-version only</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"A:0"</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>tag_retrieve</value></param>
<param><key>display</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>filter</key><value></value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tbins</value></param>
<param><key>label</key><value>Number of time bins for profile</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>250</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>thresh</value></param>
<param><key>label</key><value>RFI detection threshold--linear factor</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>2.5</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>trial_ppms</value></param>
<param><key>label</key><value>List of trial ppms</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"0.0"</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_radio</value></param>
<param><key>ant0</key><value></value></param>
<param><key>bw0</key><value>samp_rate*2.0</value></param>
<param><key>center_freq0</key><value>uhd.tune_request(freq,samp_rate/1.8)</value></param>
<param><key>dc_offs_enb0</key><value>True</value></param>
<param><key>iq_imbal_enb0</key><value>False</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>rfgain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>comment</key><value>If you enable the UHD source, disable the
gr-osmsdr source.</value></param>
<param><key>dev_addr</key><value>device</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>clock_source0</key><value>refclock</value></param>
<param><key>sd_spec0</key><value>subdev</value></param>
<param><key>time_source0</key><value>pps</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>iq</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_1</value></param>
<param><key>stream_id</key><value>d_mags</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_2</value></param>
<param><key>stream_id</key><value>f_mags</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_3</value></param>
<param><key>stream_id</key><value>pre_d_mags2</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>iq</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1</value></param>
<param><key>stream_id</key><value>d_mags</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1_0</value></param>
<param><key>stream_id</key><value>d_mags</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_2</value></param>
<param><key>stream_id</key><value>f_mags</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_3</value></param>
<param><key>stream_id</key><value>pre_d_mags2</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_4</value></param>
<param><key>stream_id</key><value>f_mags</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>wide</value></param>
<param><key>label</key><value>Enable 16-bit output</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<connection><source_block_id>analog_fastnoise_source_x_0</source_block_id><sink_block_id>blocks_stream_to_vector_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_abs_xx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_abs_xx_1</source_block_id><sink_block_id>blocks_float_to_char_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_abs_xx_1</source_block_id><sink_block_id>blocks_float_to_short_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_abs_xx_1</source_block_id><sink_block_id>blocks_keep_one_in_n_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>tag_retrieve</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_1</source_block_id><sink_block_id>virtual_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_2</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_2</source_block_id><sink_block_id>single_pole_iir_filter_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>blocks_integrate_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>single_pole_iir_filter_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_1</source_block_id><sink_block_id>single_pole_iir_filter_xx_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_char_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_short_0</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_head_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_integrate_xx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_integrate_xx_1</source_block_id><sink_block_id>single_pole_iir_filter_xx_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_1</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_2</source_block_id><sink_block_id>blocks_multiply_const_vxx_5</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_3</source_block_id><sink_block_id>blocks_vector_to_stream_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_add_xx_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_2</source_block_id><sink_block_id>blocks_add_xx_2</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_3</source_block_id><sink_block_id>blocks_add_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_4</source_block_id><sink_block_id>virtual_sink_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_5</source_block_id><sink_block_id>blocks_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>fft_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_1</source_block_id><sink_block_id>blocks_abs_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_2</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_sub_xx_0</source_block_id><sink_block_id>blocks_abs_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tags_strobe_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>blocks_integrate_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_1</source_block_id><sink_block_id>Folder_Block</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>copyblock</source_block_id><sink_block_id>blocks_complex_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>copyblock</source_block_id><sink_block_id>blocks_keep_one_in_n_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>single_pole_iir_filter_xx_0</source_block_id><sink_block_id>virtual_sink_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>single_pole_iir_filter_xx_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>single_pole_iir_filter_xx_2</source_block_id><sink_block_id>fft_probe</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>single_pole_iir_filter_xx_3</source_block_id><sink_block_id>analysis_probe</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>single_pole_iir_filter_xx_4</source_block_id><sink_block_id>blocks_stream_to_vector_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_radio</source_block_id><sink_block_id>copyblock</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>blocks_head_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1_0</source_block_id><sink_block_id>single_pole_iir_filter_xx_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_2</source_block_id><sink_block_id>blocks_keep_one_in_n_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_3</source_block_id><sink_block_id>blocks_add_xx_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>virtual_source_4</source_block_id><sink_block_id>blocks_keep_one_in_n_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
